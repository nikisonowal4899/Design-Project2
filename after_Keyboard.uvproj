# Keil uVision project after_Keyboard.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: after_Keyboard +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 code.c lcd.h lcd.c delay.h delay.c i2c.h i2c.c eeprom.h eeprom.c
